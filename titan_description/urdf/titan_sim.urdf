Commit message: improve Pixel simulation observations

File: titan_description/urdf/titan_sim.urdf (robot description, URDF)
Before this commit: robot titan, 9 links, 8 joints
Joints:
- joint RGB_Camera_Joint: origin xyz=0.13025 0 0.088971 rpy=0 0 0 -> xyz=0.10 0 0.12 rpy=0 0 0
